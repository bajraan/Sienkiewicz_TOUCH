File: Power - Sequencing.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: documentation update /requirements /schematic
Other:
- title: Power - Sequencing -> Requirements 
